options:
  parameters:
    generate_options: no_gui
    id: onpc_trans
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 2437e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '.8'
  states: {}
- name: metadata
  id: variable
  parameters:
    value: '{"pdu_num": 0,"time_type": "uhd_time_tuple","burst_time": (0,.0),}'
  states: {}
- name: samp_per_symbol
  id: variable
  parameters:
    value: int(samp_rate*symbol_len)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: symbol_len
  id: variable
  parameters:
    value: '5000e-6'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/test.iq
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.to_pmt(metadata),pmt.to_pmt(np.array([126, 209, 11, 42, 79, 6, 230, 58],dtype=np.uint8,)),)
    period: '5000'
  states: {state: disabled}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_POISSON
    mean: '1000'
    msg: pmt.intern("TEST")
  states: {state: disabled}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: int(samp_per_symbol)
    max_iter: '10000'
    scale: '1'
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_utils_pdu_to_bursts_X_0
  id: pdu_utils_pdu_to_bursts_X
  parameters:
    depth: '64'
    early_behavior: pdu_utils.EARLY_BURST_BEHAVIOR__APPEND
    type: b
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_per_symbol)
    taps: firdes.low_pass(1, samp_rate, 25000,1e6)
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    dev_addr: addr=192.168.0.11
    gain0: gain
    gain_type0: normalized
    len_tag_name: ''
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: char
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: packet
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: packet
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: char
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5557
    timeout: '100'
  states: {state: disabled}
- name: zeromq_sub_msg_source_0_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5557
    timeout: '100'
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print]
- [blocks_message_strobe_0, strobe, pdu_utils_pdu_to_bursts_X_0, bursts]
- [blocks_moving_average_xx_1, '0', blocks_float_to_complex_0, '0']
- [blocks_uchar_to_float_0, '0', virtual_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [pdu_utils_pdu_to_bursts_X_0, '0', virtual_sink_0_1, '0']
- [rational_resampler_xxx_1_0, '0', blocks_moving_average_xx_1, '0']
- [virtual_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [virtual_source_1, '0', rational_resampler_xxx_1_0, '0']
- [zeromq_sub_msg_source_0, out, blocks_message_debug_0, print]
- [zeromq_sub_msg_source_0, out, pdu_utils_pdu_to_bursts_X_0, bursts]
- [zeromq_sub_msg_source_0_0, out, blocks_message_debug_0, print]
- [zeromq_sub_msg_source_0_0, out, pdu_utils_pdu_to_bursts_X_0, bursts]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
