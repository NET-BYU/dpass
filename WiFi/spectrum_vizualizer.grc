options:
  parameters:
    generate_options: qt_gui
    id: spectrum_vizualizer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: 2.412e9
    step: '1'
    stop: 2.462e9
    value: 2.437e9
  states: {state: disabled}
- name: center_freq
  id: variable_qtgui_chooser
  parameters:
    label0: '0'
    label1: '3'
    label2: '6'
    label3: '8'
    label4: '11'
    num_opts: '5'
    option0: 2.412e9
    option1: 2.422e9
    option2: 2.437e9
    option3: 2.447e9
    option4: 2.462e9
    orient: Qt.QHBoxLayout
    type: real
    value: 2.437e9
    widget: radio_buttons
  states: {state: disabled}
- name: center_freq
  id: variable
  parameters:
    value: 5.765e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: variable_rrc_filter_taps_0
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.5'
    gain: '1.0'
    ntaps: 11*sps
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/apal6981/Downloads/temp3.iq
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*samp_rate
    samp_rate: samp_rate
    sym_rate: '1.0'
    type: fir_filter_ccf
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    dev_addr: addr=192.168.0.11
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
